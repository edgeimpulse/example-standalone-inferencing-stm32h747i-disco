# Keil uVision project example-standalone-inferencing-stm32h747i-disco.uvprojx, settings and files
target DISCO (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: example-standalone-inferencing-stm32h747i-disco
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: EI_PORTING_STM32_DISCO=1,EI_PORTING_STM32_CUBEAI=0
  c misc: -Wno-c++98-compat -Wno-c++98-compat-pedantic
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Edge Impulse
    ./: ei_main.cpp ei_main.h ei_classifier_porting.cpp
  group :STM32CubeMX_CM7:Common Sources
    ../STM32CubeMX/STCubeGenerated/CM7/Src/: main.c stm32h7xx_it.c
    ../STM32CubeMX/STCubeGenerated/CM7/Inc/: stm32h7xx_it.h
  group peripheral
    ./: uart.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.0.0, EdgeImpulse:model:Motion_recognition 1.0.44, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:HSEM 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.11.0
