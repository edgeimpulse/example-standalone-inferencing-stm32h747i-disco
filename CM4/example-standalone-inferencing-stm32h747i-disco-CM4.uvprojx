# Keil uVision project example-standalone-inferencing-stm32h747i-disco-CM4.uvprojx, settings and files
target CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example-standalone-inferencing-stm32h747i-disco-CM4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group :STM32CubeMX_CM4:Common Sources
    ../STM32CubeMX/STCubeGenerated/CM4/Src/: main.c stm32h7xx_it.c
    ../STM32CubeMX/STCubeGenerated/CM4/Inc/: stm32h7xx_it.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:HSEM 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:Startup 1.11.0
